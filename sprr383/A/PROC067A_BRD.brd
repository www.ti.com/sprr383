# Allegro board PROC067A_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
4_VCC_5V on TOP: 23.03,3.61 23.03,9.32 25.83,9.32 25.83,3.61
4_VCC_5V on BOTTOM: 23.03,3.61 23.03,9.32 25.7,9.32 25.7,3.61
4_VCC_5V on L04_SIG1: 10.13,56.82 10.13,1.09 25.92,1.09 25.92,24.91 28.62,27.61 28.62,42.48 25.64,45.47 25.64,47.12 26.02,47.5 28.94,47.5 33,43.43 33,29.72 33.33,29.39 46.27,29.39 46.31,29.43 46.31,56.82
4_VCC_12V on TOP (solid shape): outline of 319 points within 15.43,9.7 25.95,21.96
4_VCC_12V on BOTTOM: 21.99,9.7 25.95,9.7 25.95,13.89 21.99,13.89
4_VCC_12V on L03_PWR: 10.1,1.12 10.1,21.61 20.15,21.61 20.15,13.81 26.63,13.81 31.54,8.89 31.54,1.12
4_VCC_FUN_3V3 on TOP: 55.04,2.34 54.02,3.35 54.02,4.88 55.04,4.88 55.29,5.13 55.29,7.8 55.93,7.8 55.93,7.04 56.05,6.91 57.45,6.91 57.7,6.65 57.7,5.26 58.34,4.62 70.66,4.62 71.53,5.5 71.53,8.81 71.79,9.07 74.53,9.07 74.53,7.54 73.96,7.54 73.96,6.65 74.85,5.77 83.99,5.77 84.37,6.15 84.37,8.43 84.5,8.56 86.41,8.56 86.66,8.31 86.66,4.11 84.88,2.34
4_VCC_FUN_3V3 on BOTTOM: 46.46,12.24 46.46,13.54 46.45,13.54 46.35,13.64 45.95,13.64 45.86,13.73 45.86,14.19 46.03,14.37 46.29,14.37 46.52,14.6 46.52,14.9 46.63,15.01 47.9,15.01 47.9,13.58 47.73,13.41 47.73,12.24
4_VCC_FUN_3V3 on L03_PWR: 73.33,23.93 73.33,2.34 88.69,2.34 88.69,23.93
4_VCC_FUN_3V3 on L04_SIG1: 45.96,14.44 47.91,14.44 48.37,13.99 48.37,13.15 47.68,12.46 46.24,12.46 45.98,12.21 45.98,9.63 46.77,8.84 49.88,8.84 51.27,10.23 60.49,10.23 61.22,9.49 61.22,4.62 61.04,4.44 59.61,4.44 59.51,4.34 57.87,4.34 57.79,4.42 57.79,5.11 58.84,6.15 58.84,8.86 58.43,9.26 52.4,9.26 51.47,8.33 45.91,8.33 44.84,9.4 44.84,13.33
4_VCC_PCIE_3V3 on TOP: 46.29,35.1 46.29,41.67 52.52,41.67 52.52,35.1
4_VCC_PCIE_3V3 on L03_PWR: 62.61,40 36.58,40 29.97,33.38 29.97,28.98 28.46,27.47 28.46,22.49 33.92,17.03 38.13,17.03 39.27,15.9 61.69,15.9 62.61,16.81
4_VCC_PCIE_12V on TOP (solid shape): 67.59,19.71 67.59,19.07 67.46,18.95 66.7,19.71 67.07,20.25
4_VCC_PCIE_12V on TOP: 65.57,33.83 65.57,30.04 70.77,30.04 70.77,33.83
4_VCC_PCIE_12V on TOP: 22.59,21.89 26.26,21.89 26.26,15.01 21.81,15.01 21.81,18.54 22.59,18.54
4_VCC_PCIE_12V on TOP: 66.14,20.83 66.14,18.32 66.19,18.26 68.37,18.26 68.37,20.83
4_VCC_PCIE_12V on L03_PWR: 63.28,33.91 72.12,33.91 72.12,1.14 32.03,1.14 32.03,9.38 26.93,14.47 20.82,14.47 20.82,21.89 28.12,21.89 33.61,16.4 37.42,16.4 38.58,15.24 62.02,15.24 63.28,16.5
USB_SHIELD4 on TOP, BOTTOM: 22.84,53.09 22.84,56.9 23.02,57.07 36.76,57.07 36.94,56.9 36.94,52.96 36.81,52.83 29.69,52.83 29.45,53.08 29.45,54.61 29.07,54.99 26.14,54.99 26.02,54.86 26.02,53.21 25.51,52.7 23.22,52.7
USB_SHIELD4 on L02_GND1, L05_GND2: 22.84,53.09 22.84,56.9 23.02,57.07 36.76,57.07 36.94,56.9 36.94,52.96 36.81,52.83 29.92,52.83 29.45,53.31 29.45,54.61 29.07,54.99 26.14,54.99 26.02,54.86 26.02,53.21 25.51,52.7 23.22,52.7
USB_SHIELD4 on L03_PWR: 22.84,53.09 22.84,56.9 22.97,57.02 36.81,57.02 36.94,56.9 36.94,52.96 36.81,52.83 29.92,52.83 29.45,53.31 29.45,54.61 29.07,54.99 26.14,54.99 26.02,54.86 26.02,53.21 25.51,52.7 23.22,52.7
USB_SHIELD4 on L04_SIG1: 22.84,53.09 22.84,56.77 36.94,56.77 36.94,52.96 36.81,52.83 29.92,52.83 29.45,53.31 29.45,54.61 29.07,54.99 26.14,54.99 26.02,54.86 26.02,53.21 25.51,52.7 23.22,52.7
N16880317 on TOP (solid shape): 41.89,36.96 41.89,32 39.99,32 39.99,33.78 39.73,34.03 39.73,37.08 39.86,37.21 41.64,37.21
N17117476 on TOP: 14.59,26.37 15.18,25.77 15.18,24.63 15.79,24.63 15.79,25.79 16.11,26.11 16.11,33.39 11.44,33.39 11.44,26.89 14.37,26.89 14.59,26.67
N17117530 on TOP: 17.04,23.91 17.88,23.91 17.88,25.06 20.54,25.06 20.54,25.92 20.49,25.97 17.75,25.97 17.2,25.43 17.2,24.31 17.04,24.14
N17797147 on TOP: 30.72,39.37 35.92,39.37 36.18,39.62 36.18,46.61 36.05,46.74 33.15,46.74 33.02,46.86 30.72,46.86 30.46,46.61 30.46,39.62

Small or netless copper shapes (teardrops, artwork): 94 on TOP, 33 on BOTTOM, 43 on L04_SIG1

## Text on the board
Ref Des/Assembly Bottom: SER-PCIE2LEVM_REV.A_ASSEMBLY DRAWING BOTTOM
Ref Des/Silkscreen Bottom: For Evaluation only; not | FCC approved for resale
User.Comments: CR_ETHERNET_2 | BOARD NAME: | SER-PCIE2LEVM | REV: A | DATE: 26/02/2020 | DESCRIPTION: | SHEET | OF | 21 | PROC067 | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: SER-PCIE2LEVM_REV.A_ASSEMBLY DRAWING TOP
Ref Des/Silkscreen Top: USB 2.0 | PCIe x2 | EXT | RESET | INT | HOST_SEL | SL# | ASSM P/N : 4P0088 | ASSM REV : ______ | SER-PCIE2LEVM | PROC067A
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | VU | AMB | ZA | DATE | 260220 | SIZE | SCALE: | D | NONE | SHEET 1 OF 21 | PROC067 | Rev | A | REV # | TEXAS INSTRUMENTS | DESCRIPTION | REVISIONS | CCN # | SER-PCIE2LEVM | DDMMYY
User.11: 15. | 14. | PCB SHALL BE MANUFACTURED USING I-SPEED OR EQUIVALENT WITH Er 3.34. | FOR STACKUP DETAILS PROC067_STACKUP.pdf SHALL BE REFERRED | ALL NON FUNCTIONAL PAD'S OF VIA'S AND PTH HOLES SHALL BE REMOVED.
User.40: 02 | 03 | 07 | 06 | 05 | 04 | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L4 | L1,L6 | L6 | 4 | 8.2 | 8.8 | 9.2 | 8 | 14 | 5.5 | 5 | 6.2 | 7 | NA | 100 | 90 | 85 | 50 | L2,L5 | L5 | L5/L3
User.41: LAYER NAME | 0.0065 | 0.0045 | 0.0262 | LAYER STACKUP | FINISHED Cu | 1.45oz | 1oz. | X-SECTION | DIELECTRIC THICKNESS | [INCHES] | L01 | L02 | L03 | L04 | L05 | L06 | PRIMARY SIDE | PRIMARY SIDE SILKSCREEN | PRIMARY SIDE SOLDERMASK | GROUND PLANE-1 | POWER-PLANE-1 | INNER SIGNAL-1 | GROUND PLANE-2 | SECONDARY SIDE | SECONDARY SIDE SOLDERMASK | SECONDARY SIDE SILKSCREEN
User.42: FIGURE | SIZE | 8.0 | 28.0 | 34.0 | 40.0 | 44.0 | 46.0 | 32.0 | 42.0 | 56.0 | 92.0 | 108.0 | 64.0x32.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-4.0 | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 434 | 74 | 2 | 6 | 3 | 12
User.45: C147 | L3 | R229 | C133 | C137 | J13 | C129 | J5 | C127 | FL16 | J15 | C134 | FL20 | FL17 | Y6 | FL19 | C150 | U22 | C140 | C144 | R221 | R222 | C142 | U20 | R211 | C130 | U25 | C151 | R247 | J14 | U24 | C148 | C136 | C132 | C135 | R237 | R244 | C155 | C153 | R235 | C158 | R228 | R224 | R225 | C139 | U23 | C145 | C154 | C146 | R232 | R239 | FL18 | R219 | R223 | C141 | C143 | R220 | C131 | C128 | U21 | R212 | R214 | R243 | R215 | R217 | R218 | C160 | C149 | C152 | R240 | R241 | R238 | R226 | R242 | C138 | R227 | C159 | R213 | PROC067 E3 ASSEMBLY BOTTOM | PROC067A ASSEMBLY BOTTOM | 1 - All MSL components should be baked as per JEDEC standard. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | ASSEMBLY NOTES:- | 2 - PCB should be baked at 120 degree for 8 hours. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment.
